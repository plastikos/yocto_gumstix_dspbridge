PR = "r1"

SRC_URI[md5sum] = "4a460d7974f271c2e686ada8ddf2a117"

XTRACT_ARGS = "--mode silent"

include ti-xdctools-common.inc
