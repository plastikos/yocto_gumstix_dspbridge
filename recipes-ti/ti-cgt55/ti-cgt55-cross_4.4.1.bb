PR = "r1"

require ti-cgt55.inc

SRC_URI[md5sum] = "8b0b3b8e108ae4370a77cdc956c1f900"
SRC_URI[sha256sum] = "ffe2f5f2670b98c5c2e5629bcd3105fb01ca85ee9f66e064b7a7c377feaacbe2"
