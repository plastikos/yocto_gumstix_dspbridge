require u-boot.inc

PR = "r10"

COMPATIBLE_MACHINE = "overo"

SRCREV = "git://git.denx.de/u-boot.git;branch=master;protocol=git"
SPL_BINARY = "MLO"
