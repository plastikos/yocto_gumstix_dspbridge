require ti-framework-components.inc

PR = "r1"

SRC_URI[md5sum] = "69efa43d1b17626a943a6e61b8b5b285"
SRC_URI[sha256sum] = "f6077a615c771ef7e7f3d0b0a66d24191403a497b45220a6d50fc2a1ced4b105"
