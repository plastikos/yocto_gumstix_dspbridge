require ti-framework-components.inc

PR = "r1"

SRC_URI[md5sum] = "8c4af719af2cd800cfa7cf6921d44a5f"
