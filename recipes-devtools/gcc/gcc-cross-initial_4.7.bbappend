DEPENDS += "texinfo-native"
