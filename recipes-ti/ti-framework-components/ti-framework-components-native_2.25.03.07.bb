include ti-framework-components-common.inc

PR = "r1"

SRC_URI[md5sum] = "46ab914159f25022942ae8249da31c97"
