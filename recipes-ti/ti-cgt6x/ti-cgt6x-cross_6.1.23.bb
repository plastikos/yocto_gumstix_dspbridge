PR = "r1"

require ti-cgt6x.inc

SRC_URI[md5sum] = "341937787ac775a88f7ac3428342d7e8"
SRC_URI[sha256sum] = "e785b0af55e2390ff430df9082070ccf20b9b2e8ce4eb51dd31ca696748c40df"
