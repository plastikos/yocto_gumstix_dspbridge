PR = "r1"

require ti-cgt6x.inc

SRC_URI[md5sum] = "97c6fa114527c386065d9b61318a7cc7"
SRC_URI[sha256sum] = "7be9e80788501d45ca2924fa6659a9bbe81ad40e434c27ca0661d2ab27e95520"
