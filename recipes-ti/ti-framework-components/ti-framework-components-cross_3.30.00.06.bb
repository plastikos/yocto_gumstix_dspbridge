require ti-framework-components.inc

PR = "r1"

SRC_URI[md5sum] = "1ab8f8ad54736763df263ed10fdea7f2"
