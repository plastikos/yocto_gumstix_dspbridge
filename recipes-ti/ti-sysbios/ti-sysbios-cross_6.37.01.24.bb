require ${PN}.inc

PR = "r1"

SRC_URI[md5sum] = "4636cb558513e106678abaa0dd9f10ab"
SRC_URI[sha256sum] = "726633d3c2d98638c35b6cb53b9baf278dab1ab9fdbb3622387ce6663cc3e677"

XTRACT_ARGS = "--mode unattended"
