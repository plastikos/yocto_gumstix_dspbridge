PR = "r1"

require ti-cgt6x.inc

SRC_URI[md5sum] = "a4ff6ebf4f76547b44544e660c1c888e"
