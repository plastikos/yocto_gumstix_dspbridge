PR = "r1"

XTRACT_ARGS = "--mode silent"

require ti-xdctools.inc

SRC_URI = "http://software-dl.ti.com/targetcontent/legacy_files/targetcontent/rtsc/xdctools_3_10/xdctools_${TI_PV}/exports/${TI_PKG}"

SRC_URI[md5sum] = "94f910da423127ab91b285ecc0ec919b"
SRC_URI[sha256sum] = "0c999e327dc5035b7e7bc46a0f8c7451e8a0bfdbd8dcac23f1ceba666805cee1"
