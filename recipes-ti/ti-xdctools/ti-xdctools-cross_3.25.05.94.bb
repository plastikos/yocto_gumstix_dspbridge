PR = "r1"

XTRACT_ARGS = "--mode unattended"

require ti-xdctools.inc

SRC_URI = "http://downloads.ti.com/dsps/dsps_public_sw/sdo_sb/targetcontent/rtsc/${TI_PV}/exports/${TI_PKG}"

SRC_URI[md5sum] = "38eb5184a3a857cfca2e99cfe232ae5e"
