PR = "r1"

XTRACT_ARGS = "--mode silent"

require ti-xdctools.inc

SRC_URI = "http://downloads.ti.com/dsps/dsps_public_sw/sdo_sb/targetcontent/rtsc/${TI_PV}/exports/${TI_PKG}"

SRC_URI[md5sum] = "068447e935adb54f0cacf0e294a281f9"
SRC_URI[sha256sum] = "a4616fae3cc2a9f46b5b4377bb57af7f7932297cda210a6cbcc5f942256db196"
